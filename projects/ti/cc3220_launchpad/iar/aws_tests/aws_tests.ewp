# IAR project aws_tests.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3220SF TexasInstruments CC3220SF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; CONFIG_MEDTLS_USE_AFR_MEMORY; _DLIB_FILE_DESCRIPTOR; FREERTOS_ENABLE_UNIT_TESTS; UNITY_INCLUDE_CONFIG_H
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc; $TOOLKIT_DIR$\inc\c; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\vendors\ti\SimpleLink_CC32xx\v2_10_00_04\source; ..\..\..\..\..\vendors\ti\boards\cc3220_launchpad\aws_tests\config_files; ..\..\..\..\..\vendors\ti\boards\cc3220_launchpad\aws_tests\application_code\ti_code; ..\..\..\..\..\tests\include; ..\..\..\..\..\freertos_kernel\portable\IAR\ARM_CM3; ..\..\..\..\..\libraries\abstractions\posix\include; ..\..\..\..\..\vendors\ti\boards\cc3220_launchpad\ports\posix; ..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_posix\include; ..\..\..\..\..\libraries\c_sdk\standard\common\include\private; ..\..\..\..\..\libraries\abstractions\posix\include\FreeRTOS_POSIX; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include; ..\..\..\..\..\libraries\abstractions\platform\include\platform; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\libraries\logging\include; ..\..\..\..\..\demos\dev_mode_key_provisioning\include; ..\..\..\..\..\libraries\abstractions\pkcs11\corePKCS11\source\include; ..\..\..\..\..\libraries\freertos_plus\aws\ota\test; ..\..\..\..\..\libraries\freertos_plus\standard\crypto\include; ..\..\..\..\..\libraries\freertos_plus\standard\utils\include; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\libraries\c_sdk\aws\defender\include; ..\..\..\..\..\libraries\c_sdk\aws\defender\src; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\access; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\mock; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\include; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\src; ..\..\..\..\..\libraries\coreMQTT\source\include; ..\..\..\..\..\libraries\coreMQTT\source\interface; ..\..\..\..\..\libraries\abstractions\backoff_algorithm\source\include; ..\..\..\..\..\demos\common\pkcs11_helpers; ..\..\..\..\..\libraries\abstractions\transport\secure_sockets; ..\..\..\..\..\libraries\c_sdk\standard\serializer\include; ..\..\..\..\..\libraries\c_sdk\aws\shadow\include; ..\..\..\..\..\libraries\c_sdk\aws\shadow\src; ..\..\..\..\..\libraries\c_sdk\standard\https\test\access; ..\..\..\..\..\libraries\c_sdk\standard\https\include; ..\..\..\..\..\libraries\c_sdk\standard\https\src; ..\..\..\..\..\libraries\coreHTTP\source\include; ..\..\..\..\..\libraries\coreHTTP\source\interface; ..\..\..\..\..\libraries\coreHTTP\source\dependency\3rdparty\http_parser; ..\..\..\..\..\demos\common\http_demo_helpers; ..\..\..\..\..\libraries\freertos_plus\aws\greengrass\test; ..\..\..\..\..\libraries\freertos_plus\aws\greengrass\include; ..\..\..\..\..\libraries\freertos_plus\aws\greengrass\src; ..\..\..\..\..\libraries\freertos_plus\aws\ota\src; ..\..\..\..\..\libraries\freertos_plus\aws\ota\include; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_cli\include; ..\..\..\..\..\libraries\coreJSON\source\include; ..\..\..\..\..\libraries\device_shadow_for_aws\source\include; ..\..\..\..\..\demos\common\mqtt_demo_helpers; ..\..\..\..\..\libraries\device_defender_for_aws\source\include; ..\..\..\..\..\libraries\jobs_for_aws\source\include; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\..\..\libraries\3rdparty\pkcs11; ..\..\..\..\..\libraries\3rdparty\mbedtls_config; ..\..\..\..\..\libraries\3rdparty\mbedtls\include\mbedtls; ..\..\..\..\..\libraries\3rdparty\mbedtls_utils; ..\..\..\..\..\libraries\3rdparty\tinycbor\src; ..\..\..\..\..\libraries\3rdparty\jsmn
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLER__
  AARM.AUserIncludes: ..\..\..\..\..\vendors\ti\boards\cc3220_launchpad\aws_tests\config_files
  OBJCOPY.OOCOutputFile: aws_tests.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\vendors\ti\SimpleLink_CC32xx\v2_10_00_04\source\ti\boards\CC3220SF_LAUNCHXL\CC3220SF_LAUNCHXL_FREERTOS.icf
  ILINK.IlinkExtraOptions: ..\..\..\..\..\vendors\ti\SimpleLink_CC32xx\v2_10_00_04\source\ti\drivers\net\wifi\iar\rtos\simplelink.a; ..\..\..\..\..\vendors\ti\SimpleLink_CC32xx\v2_10_00_04\source\ti\devices\cc32xx\driverlib\iar\Release\driverlib.a; ..\..\..\..\..\vendors\ti\SimpleLink_CC32xx\v2_10_00_04\source\ti\drivers\lib\drivers_cc32xx.arm4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group freertos_kernel
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/include
    ../../../../../freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group freertos_kernel/portable/MemMang
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group freertos_kernel/portable/IAR/ARM_CM3
    ../../../../../freertos_kernel/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group vendors/ti/boards/cc3220_launchpad
    ../../../../../vendors/ti/boards/cc3220_launchpad/: CC3220SF.ccxml
  group vendors/ti/boards/cc3220_launchpad/ports/posix
    ../../../../../vendors/ti/boards/cc3220_launchpad/ports/posix/: FreeRTOS_POSIX_portable.h
  group vendors/ti/boards/cc3220_launchpad/ports/secure_sockets
    ../../../../../vendors/ti/boards/cc3220_launchpad/ports/secure_sockets/: iot_secure_sockets.c
  group vendors/ti/boards/cc3220_launchpad/ports/pkcs11
    ../../../../../vendors/ti/boards/cc3220_launchpad/ports/pkcs11/: core_pkcs11_pal.c
  group vendors/ti/boards/cc3220_launchpad/ports/wifi
    ../../../../../vendors/ti/boards/cc3220_launchpad/ports/wifi/: iot_wifi.c
  group vendors/ti/boards/cc3220_launchpad/ports/ota
    ../../../../../vendors/ti/boards/cc3220_launchpad/ports/ota/: aws_ota_pal.c
  group vendors/ti/boards/cc3220_launchpad/aws_tests/application_code
    ../../../../../vendors/ti/boards/cc3220_launchpad/aws_tests/application_code/: main.c
  group vendors/ti/boards/cc3220_launchpad/aws_tests/application_code/ti_code
    ../../../../../vendors/ti/boards/cc3220_launchpad/aws_tests/application_code/ti_code/: CC3220SF_LAUNCHXL.c network_if.c uart_term.c Board.h CC3220SF_LAUNCHXL.h network_if.h uart_term.h CC3220SF_LAUNCHXL_FREERTOS.cmd
  group vendors/ti/boards/cc3220_launchpad/aws_tests/config_files
    ../../../../../vendors/ti/boards/cc3220_launchpad/aws_tests/config_files/: FreeRTOSConfig.h FreeRTOSIPConfig.h aws_bufferpool_config.h aws_ggd_config.h aws_iot_network_config.h aws_mqtt_config.h aws_ota_agent_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_ota_config.h aws_test_runner_config.h aws_test_tcp_config.h iot_test_wifi_config.h aws_wifi_config.h core_http_config.h core_mqtt_config.h core_pkcs11_config.h core_test_pkcs11_config.h defender_config.h iot_config.h iot_mqtt_agent_config.h shadow_config.h unity_config.h
  group vendors/ti/SimpleLink_CC32xx/v2_10_00_04/kernel/freertos/dpl
    ../../../../../vendors/ti/SimpleLink_CC32xx/v2_10_00_04/kernel/freertos/dpl/: ClockP_freertos.c DebugP_freertos.c HwiPCC32XX_freertos.c MutexP_freertos.c PowerCC32XX_freertos.c SemaphoreP_freertos.c SystemP_freertos.c
  group vendors/ti/SimpleLink_CC32xx/v2_10_00_04/kernel/freertos/startup
    ../../../../../vendors/ti/SimpleLink_CC32xx/v2_10_00_04/kernel/freertos/startup/: startup_cc32xx_iar.c
  group libraries/abstractions/posix/include/FreeRTOS_POSIX
    ../../../../../libraries/abstractions/posix/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group libraries/abstractions/posix/include/FreeRTOS_POSIX/sys
    ../../../../../libraries/abstractions/posix/include/FreeRTOS_POSIX/sys/: types.h
  group libraries/abstractions/platform/include/platform
    ../../../../../libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h iot_metrics.h
  group libraries/abstractions/platform/include/types
    ../../../../../libraries/abstractions/platform/include/types/: iot_platform_types.h
  group libraries/abstractions/platform/freertos
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c iot_metrics.c iot_network_freertos.c
  group libraries/abstractions/platform/freertos/include/platform
    ../../../../../libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h iot_network_freertos.h
  group libraries/abstractions/platform/test
    ../../../../../libraries/abstractions/platform/test/: iot_test_platform_clock.c iot_test_platform_threads.c
  group libraries/abstractions/secure_sockets/include
    ../../../../../libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group libraries/abstractions/secure_sockets/test
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
  group libraries/abstractions/pkcs11/corePKCS11/source
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group libraries/abstractions/pkcs11/corePKCS11/source/include
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/include/: core_pkcs11.h core_pkcs11_pal.h core_pki_utils.h
  group libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group libraries/abstractions/pkcs11/test
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
  group libraries/abstractions/wifi/include
    ../../../../../libraries/abstractions/wifi/include/: iot_wifi.h
  group libraries/abstractions/wifi/test
    ../../../../../libraries/abstractions/wifi/test/: iot_test_wifi.c
  group libraries/abstractions/backoff_algorithm/source
    ../../../../../libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group libraries/abstractions/backoff_algorithm/source/include
    ../../../../../libraries/abstractions/backoff_algorithm/source/include/: backoff_algorithm.h
  group libraries/abstractions/transport/secure_sockets
    ../../../../../libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.h transport_secure_sockets.c
  group libraries/freertos_plus/standard/freertos_plus_posix/source
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group libraries/freertos_plus/standard/freertos_plus_posix/include
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_types.h FreeRTOS_POSIX_internal.h FreeRTOS_POSIX_portable_default.h
  group libraries/freertos_plus/standard/freertos_plus_posix/test
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/test/: iot_test_posix_clock.c iot_test_posix_mqueue.c iot_test_posix_pthread.c iot_test_posix_semaphore.c iot_test_posix_stress.c iot_test_posix_timer.c iot_test_posix_unistd.c iot_test_posix_utils.c
  group libraries/freertos_plus/standard/crypto/src
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/crypto/include
    ../../../../../libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries/freertos_plus/standard/crypto/test
    ../../../../../libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
  group libraries/freertos_plus/standard/utils/src
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group libraries/freertos_plus/standard/utils/include
    ../../../../../libraries/freertos_plus/standard/utils/include/: iot_system_init.h
  group libraries/freertos_plus/standard/freertos_plus_cli/source
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/source/: FreeRTOS_CLI.c FreeRTOS_CLI_Console.c
  group libraries/freertos_plus/standard/freertos_plus_cli/utest
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/utest/: iot_test_freertos_cli.c iot_test_freertos_cli_console.c
  group libraries/freertos_plus/standard/tls/test
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group libraries/freertos_plus/aws/greengrass/src
    ../../../../../libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group libraries/freertos_plus/aws/greengrass/include
    ../../../../../libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group libraries/freertos_plus/aws/greengrass/test
    ../../../../../libraries/freertos_plus/aws/greengrass/test/: aws_test_ggd_system.c aws_test_ggd_unit.c aws_test_helper_secure_connect.c
  group libraries/freertos_plus/aws/ota/include
    ../../../../../libraries/freertos_plus/aws/ota/include/: aws_iot_ota_agent.h aws_iot_ota_types.h
  group libraries/freertos_plus/aws/ota/src
    ../../../../../libraries/freertos_plus/aws/ota/src/: aws_iot_ota_agent_internal.h aws_iot_ota_agent.c aws_iot_ota_interface.c aws_iot_ota_interface.h aws_iot_ota_pal.h
  group libraries/freertos_plus/aws/ota/src/mqtt
    ../../../../../libraries/freertos_plus/aws/ota/src/mqtt/: aws_iot_ota_cbor_internal.h aws_iot_ota_cbor.c aws_iot_ota_cbor.h aws_iot_ota_mqtt.c aws_iot_ota_mqtt.h
  group libraries/freertos_plus/aws/ota/src/http
    ../../../../../libraries/freertos_plus/aws/ota/src/http/: aws_iot_ota_http.c aws_iot_ota_http.h
  group libraries/freertos_plus/aws/ota/test
    ../../../../../libraries/freertos_plus/aws/ota/test/: aws_test_ota_agent.c aws_test_ota_pal.c
  group libraries/c_sdk/standard/common
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c iot_static_memory_common.c iot_device_metrics.c
  group libraries/c_sdk/standard/common/include
    ../../../../../libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_init.h iot_linear_containers.h iot_taskpool.h
  group libraries/c_sdk/standard/common/include/types
    ../../../../../libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group libraries/c_sdk/standard/common/include/private
    ../../../../../libraries/c_sdk/standard/common/include/private/: iot_taskpool_internal.h
  group libraries/c_sdk/standard/common/taskpool
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/common/test
    ../../../../../libraries/c_sdk/standard/common/test/: iot_memory_leak.c iot_tests_taskpool.c
  group libraries/c_sdk/standard/mqtt/src
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c iot_mqtt_context_connection.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_managed_function_wrapper.c iot_mqtt_subscription_container.c iot_mqtt_mutex_wrapper.c iot_mqtt_agent.c
  group libraries/c_sdk/standard/mqtt/test
    ../../../../../libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
  group libraries/c_sdk/standard/mqtt/test/mock
    ../../../../../libraries/c_sdk/standard/mqtt/test/mock/: iot_tests_mqtt_mock.c
  group libraries/c_sdk/standard/mqtt/test/unit
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c iot_tests_mqtt_metrics.c
  group libraries/c_sdk/standard/mqtt/test/system
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group libraries/c_sdk/standard/serializer/src
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_serializer_static_memory.c iot_json_utils.c
  group libraries/c_sdk/standard/serializer/src/cbor
    ../../../../../libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group libraries/c_sdk/standard/serializer/src/json
    ../../../../../libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group libraries/c_sdk/standard/serializer/include
    ../../../../../libraries/c_sdk/standard/serializer/include/: iot_serializer.h iot_json_utils.h
  group libraries/c_sdk/standard/serializer/test
    ../../../../../libraries/c_sdk/standard/serializer/test/: iot_tests_serializer_cbor.c iot_tests_serializer_json.c iot_tests_deserializer_json.c
  group libraries/c_sdk/standard/https/src
    ../../../../../libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group libraries/c_sdk/standard/https/test/unit
    ../../../../../libraries/c_sdk/standard/https/test/unit/: iot_tests_https_client.c iot_tests_https_utils.c iot_tests_https_common.c iot_tests_https_sync.c iot_tests_https_async.c
  group libraries/c_sdk/standard/https/test/system
    ../../../../../libraries/c_sdk/standard/https/test/system/: iot_tests_https_system.c
  group libraries/c_sdk/aws/defender/src
    ../../../../../libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group libraries/c_sdk/aws/defender/src/private
    ../../../../../libraries/c_sdk/aws/defender/src/private/: aws_iot_defender_internal.h
  group libraries/c_sdk/aws/defender/include
    ../../../../../libraries/c_sdk/aws/defender/include/: aws_iot_defender.h
  group libraries/c_sdk/aws/defender/test/unit
    ../../../../../libraries/c_sdk/aws/defender/test/unit/: aws_iot_tests_defender_unit.c
  group libraries/c_sdk/aws/defender/test/system
    ../../../../../libraries/c_sdk/aws/defender/test/system/: aws_iot_tests_defender_system.c
  group libraries/c_sdk/aws/shadow/src
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group libraries/c_sdk/aws/shadow/include
    ../../../../../libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group libraries/c_sdk/aws/shadow/test
    ../../../../../libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
  group libraries/c_sdk/aws/shadow/test/unit
    ../../../../../libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
  group libraries/c_sdk/aws/shadow/test/system
    ../../../../../libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
  group libraries/logging
    ../../../../../libraries/logging/: iot_logging_task_dynamic_buffers.c iot_logging.c
  group libraries/logging/include
    ../../../../../libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group libraries/3rdparty/mbedtls_config
    ../../../../../libraries/3rdparty/mbedtls_config/: threading_alt.h
  group libraries/3rdparty/mbedtls/library
    ../../../../../libraries/3rdparty/mbedtls/library/: base64.c aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/mbedtls/include/mbedtls
    ../../../../../libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group libraries/3rdparty/unity/src
    ../../../../../libraries/3rdparty/unity/src/: unity.c unity.h unity_internals.h
  group libraries/3rdparty/unity/extras/fixture/src
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group libraries/3rdparty/mbedtls_utils
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_utils.c mbedtls_error.h mbedtls_error.c
  group libraries/3rdparty/pkcs11
    ../../../../../libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group libraries/3rdparty/tinycbor/src
    ../../../../../libraries/3rdparty/tinycbor/src/: cborpretty.c cborpretty_stdio.c cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c
  group libraries/3rdparty/jsmn
    ../../../../../libraries/3rdparty/jsmn/: jsmn.h jsmn.c
  group libraries/coreMQTT/source
    ../../../../../libraries/coreMQTT/source/: core_mqtt.c core_mqtt_state.c core_mqtt_serializer.c
  group libraries/coreMQTT/source/include
    ../../../../../libraries/coreMQTT/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_serializer.h core_mqtt_state.h
  group libraries/coreMQTT/source/interface
    ../../../../../libraries/coreMQTT/source/interface/: transport_interface.h
  group libraries/coreHTTP/source
    ../../../../../libraries/coreHTTP/source/: core_http_client.c
  group libraries/coreHTTP/source/dependency/3rdparty/http_parser
    ../../../../../libraries/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c http_parser.h
  group libraries/coreHTTP/source/include
    ../../../../../libraries/coreHTTP/source/include/: core_http_client.h core_http_client_private.h core_http_config_defaults.h
  group libraries/coreHTTP/source/interface
    ../../../../../libraries/coreHTTP/source/interface/: transport_interface.h
  group libraries/coreJSON/source
    ../../../../../libraries/coreJSON/source/: core_json.c
  group libraries/coreJSON/source/include
    ../../../../../libraries/coreJSON/source/include/: core_json.h
  group libraries/device_shadow_for_aws/source
    ../../../../../libraries/device_shadow_for_aws/source/: shadow.c
  group libraries/device_shadow_for_aws/source/include
    ../../../../../libraries/device_shadow_for_aws/source/include/: shadow.h shadow_config_defaults.h
  group libraries/device_defender_for_aws/source
    ../../../../../libraries/device_defender_for_aws/source/: defender.c
  group libraries/device_defender_for_aws/source/include
    ../../../../../libraries/device_defender_for_aws/source/include/: defender.h defender_config_defaults.h
  group libraries/jobs_for_aws/source
    ../../../../../libraries/jobs_for_aws/source/: jobs.c
  group libraries/jobs_for_aws/source/include
    ../../../../../libraries/jobs_for_aws/source/include/: jobs.h
  group tests/common
    ../../../../../tests/common/: aws_test_framework.c aws_test_runner.c aws_test.c iot_test_freertos.c iot_tests_network.c
  group tests/include
    ../../../../../tests/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_test_runner.h aws_test_framework.h aws_test_tcp.h aws_test_utils.h aws_unity_config.h iot_config_common.h
  group tests/integration_test
    ../../../../../tests/integration_test/: core_mqtt_system_test.c shadow_system_test.c core_http_system_test.c
  group demos/dev_mode_key_provisioning/src
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group demos/dev_mode_key_provisioning/include
    ../../../../../demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group demos/common/pkcs11_helpers
    ../../../../../demos/common/pkcs11_helpers/: pkcs11_helpers.c
  group demos/common/http_demo_helpers
    ../../../../../demos/common/http_demo_helpers/: http_demo_utils.c
  group demos/common/mqtt_demo_helpers
    ../../../../../demos/common/mqtt_demo_helpers/: mqtt_demo_helpers.c
