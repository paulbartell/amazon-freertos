# Keil uVision project aws_tests.uvprojx, settings and files
target aws_tests (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.1
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aws_tests +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: MBEDTLS_CONFIG_FILE="<aws_mbedtls_config.h>" CONFIG_MEDTLS_USE_AFR_MEMORY PCFG_OS=2 _REENT_SMALL PRODUCT_VERSION=7687 MTK_BLE_SMTCN_ENABLE MTK_BT_LWIP_ENABLE MTK_BLE_BQB_TEST_ENABLE MTK_BLE_CLI_ENABLE MTK_BLE_BQB_CLI_ENABLE MTK_HCI_CONSOLE_MIX_ENABLE MTK_MINISUPP_ENABLE MTK_BSPEXT_ENABLE MTK_HAL_LOWPOWER_ENABLE MTK_LWIP_CLI_ENABLE MTK_HTTPCLIENT_SSL_ENABLE MTK_IPERF_ENABLE MTK_SMTCN_ENABLE MTK_CLI_TEST_MODE_ENABLE MTK_WIFI_REPEATER_ENABLE  CONFIG_REPEATER MTK_DEBUG_LEVEL_NONE MTK_WIFI_PRIVILEGE_ENABLE SUPPORT_MBEDTLS __MTK_BLE_ONLY_ENABLE__ MTK_SINGLE_SKU_SUPPORT HAL_DFS_MODULE_ENABLED LWIP_NO_STDINT_H=1 LWIP_TIMEVAL_PRIVATE=1 __little_endian__=1 FREERTOS_ENABLE_UNIT_TESTS UNITY_INCLUDE_CONFIG_H
  c misc: --C99
  c include: ../../../../../freertos_kernel/include;../../../../../freertos_kernel/portable/RVDS/ARM_CM4F;../../../../../vendors/mediatek/sdk/kernel/service/inc;../../../../../vendors/mediatek/sdk/driver/CMSIS/Device/MTK/mt7687/Include;../../../../../vendors/mediatek/sdk/driver/CMSIS/Include;../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/common/include;../../../../../vendors/mediatek/sdk/driver/chip/inc;../../../../../vendors/mediatek/sdk/driver/chip/mt7687/inc;../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/wifi/inc;../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/ept/inc;../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/util/inc;../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/external_flash/inc;../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/config_files;../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/application_code/mediatek_code;../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/application_code/mediatek_code/include;../../../../../tests/include;../../../../../libraries/c_sdk/standard/mqtt/include;../../../../../libraries/c_sdk/standard/common/include;../../../../../libraries/3rdparty/pkcs11;../../../../../libraries/abstractions/secure_sockets/include;../../../../../libraries/c_sdk/standard/common/include/private;../../../../../libraries/freertos_plus/standard/utils/include;../../../../../libraries/abstractions/pkcs11/corePKCS11/source/include;../../../../../libraries/3rdparty/tracealyzer_recorder/Include;../../../../../libraries/abstractions/platform/include;../../../../../libraries/abstractions/platform/freertos/include;../../../../../libraries/abstractions/platform/include/platform;../../../../../libraries/freertos_plus/standard/tls/include;../../../../../libraries/freertos_plus/standard/crypto/include;../../../../../libraries/freertos_plus/aws/ota/test;../../../../../libraries/freertos_plus/standard/crypto/include;../../../../../libraries/abstractions/wifi/include;../../../../../vendors/mediatek/lwip/include;../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/wifi/inc;../../../../../vendors/mediatek/sdk/middleware/MTK/minisupp/inc;../../../../../vendors/mediatek/sdk/middleware/third_party/ping/inc;../../../../../vendors/mediatek/sdk/middleware/MTK/dhcpd/inc;../../../../../libraries/logging/include;../../../../../demos/dev_mode_key_provisioning/include;../../../../../libraries/c_sdk/aws/defender/include;../../../../../libraries/c_sdk/aws/defender/src;../../../../../libraries/c_sdk/standard/mqtt/test/access;../../../../../libraries/c_sdk/standard/mqtt/test/mock;../../../../../libraries/c_sdk/standard/mqtt/src;../../../../../libraries/coreMQTT/source/include;../../../../../libraries/coreMQTT/source/interface;../../../../../libraries/abstractions/backoff_algorithm/source/include;../../../../../demos/common/pkcs11_helpers;../../../../../libraries/abstractions/transport/secure_sockets;../../../../../libraries/c_sdk/standard/serializer/include;../../../../../libraries/c_sdk/aws/shadow/include;../../../../../libraries/c_sdk/aws/shadow/src;../../../../../libraries/c_sdk/standard/https/test/access;../../../../../libraries/c_sdk/standard/https/include;../../../../../libraries/c_sdk/standard/https/src;../../../../../libraries/coreHTTP/source/include;../../../../../libraries/coreHTTP/source/interface;../../../../../libraries/coreHTTP/source/dependency/3rdparty/http_parser;../../../../../demos/common/http_demo_helpers;../../../../../libraries/freertos_plus/aws/greengrass/test;../../../../../libraries/freertos_plus/aws/greengrass/include;../../../../../libraries/freertos_plus/aws/greengrass/src;../../../../../libraries/freertos_plus/standard/freertos_plus_cli/include;../../../../../libraries/coreJSON/source/include;../../../../../libraries/device_shadow_for_aws/source/include;../../../../../demos/common/mqtt_demo_helpers;../../../../../demos/include;../../../../../libraries/device_defender_for_aws/source/include;../../../../../libraries/jobs_for_aws/source/include;../../../../../libraries/3rdparty/mbedtls/include;../../../../../libraries/3rdparty/mbedtls_config;../../../../../libraries/3rdparty/mbedtls/include/mbedtls;../../../../../libraries/3rdparty/mbedtls_utils;../../../../../libraries/3rdparty/lwip/src/include;../../../../../libraries/3rdparty/lwip_osal/include;../../../../../libraries/3rdparty/unity/src;../../../../../libraries/3rdparty/unity/extras/fixture/src;../../../../../libraries/3rdparty/tinycbor/src;../../../../../libraries/3rdparty/jsmn
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: ..\..\..\..\..\vendors\mediatek\boards\mt7697hx-dev-kit\aws_tests\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
  group mediatek/prebuilt
    ../../../../../vendors/mediatek/sdk/prebuilt/keil/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib libkservice_CM4_MT7687_Keil.lib libminicli_CM4_Keil.lib libminisupp_CM4_Keil.lib libwifi_CM4_Keil.lib
  group freertos_kernel/
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/include/
    ../../../../../freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group vendors/mediatek/sdk/driver/board/mt76x7_hdk/ept/src/
    ../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
  group vendors/mediatek/sdk/driver/chip/mt7687/src/common/
    ../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/common/: hal_lp.c cos_api.c dma.c flash_sfc.c gpt.c hal_gdma_internal.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_pcnt.c hal_pdma_internal.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
  group vendors/mediatek/sdk/kernel/extend/src/
    ../../../../../vendors/mediatek/sdk/kernel/extend/src/: wrap_heap.c
  group vendors/mediatek/sdk/kernel/extend/src/RVDS/
    ../../../../../vendors/mediatek/sdk/kernel/extend/src/RVDS/: port.c port_tick.c
  group vendors/mediatek/sdk/driver/chip/mt7687/src/
    ../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_dfs.c hal_eint.c hal_file.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_misc.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_wdt.c
  group vendors/mediatek/sdk/driver/chip/mt7687/src/sdio_gen3/
    ../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/sdio_gen3/: connsys_bus.c connsys_driver.c connsys_util.c context_dump.c
  group libraries/3rdparty/tracealyzer_recorder/
    ../../../../../libraries/3rdparty/tracealyzer_recorder/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
  group tests/common/
    ../../../../../tests/common/: aws_test_framework.c aws_test_runner.c aws_test.c iot_test_freertos.c iot_tests_network.c
  group tests/include/
    ../../../../../tests/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_test_runner.h aws_test_framework.h aws_test_tcp.h aws_test_utils.h aws_unity_config.h iot_config_common.h
  group libraries/c_sdk/standard/common/
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c iot_static_memory_common.c iot_device_metrics.c
  group libraries/c_sdk/standard/common/include/
    ../../../../../libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_init.h iot_linear_containers.h iot_taskpool.h
  group libraries/c_sdk/standard/common/include/types/
    ../../../../../libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group libraries/c_sdk/standard/common/taskpool/
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/common/include/private/
    ../../../../../libraries/c_sdk/standard/common/include/private/: iot_taskpool_internal.h
  group libraries/abstractions/platform/include/platform/
    ../../../../../libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h iot_metrics.h
  group libraries/abstractions/platform/include/types/
    ../../../../../libraries/abstractions/platform/include/types/: iot_platform_types.h
  group libraries/abstractions/platform/freertos/
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c iot_metrics.c iot_network_freertos.c
  group libraries/abstractions/platform/freertos/include/platform/
    ../../../../../libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h iot_network_freertos.h
  group libraries/abstractions/secure_sockets/include/
    ../../../../../libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group libraries/abstractions/secure_sockets/lwip/
    ../../../../../libraries/abstractions/secure_sockets/lwip/: iot_secure_sockets.c
  group libraries/freertos_plus/standard/tls/src/
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/standard/tls/include/
    ../../../../../libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group libraries/freertos_plus/standard/crypto/src/
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/crypto/include/
    ../../../../../libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries/abstractions/pkcs11/corePKCS11/source/include/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/include/: core_pkcs11.h core_pki_utils.h
  group libraries/abstractions/pkcs11/corePKCS11/source/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group vendors/mediatek/boards/mt7697hx-dev-kit/ports/pkcs11/
    ../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/ports/pkcs11/: core_pkcs11_pal.c
  group libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group libraries/freertos_plus/standard/utils/src/
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group libraries/freertos_plus/standard/utils/include/
    ../../../../../libraries/freertos_plus/standard/utils/include/: iot_system_init.h
  group libraries/abstractions/wifi/include/
    ../../../../../libraries/abstractions/wifi/include/: iot_wifi.h
  group vendors/mediatek/boards/mt7697hx-dev-kit/ports/wifi/
    ../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/ports/wifi/: iot_wifi.c
  group vendors/mediatek/sdk/middleware/MTK/dhcpd/src/
    ../../../../../vendors/mediatek/sdk/middleware/MTK/dhcpd/src/: dhcpd.c
  group vendors/mediatek/sdk/middleware/third_party/ping/src/
    ../../../../../vendors/mediatek/sdk/middleware/third_party/ping/src/: ping.c
  group vendors/mediatek/sdk/driver/board/mt76x7_hdk/util/src/
    ../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/util/src/: io_def.c
  group vendors/mediatek/sdk/driver/board/mt76x7_hdk/wifi/src/
    ../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/wifi/src/: get_profile_string.c misc.c os.c wifi_default_config.c wifi_init.c wifi_os_api.c wifi_profile.c wifi_os_mem.c
  group vendors/mediatek/sdk/driver/board/mt76x7_hdk/external_flash/src/
    ../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
  group vendors/mediatek/lwip/src/
    ../../../../../vendors/mediatek/lwip/src/: lwipopts.c lwip_log.c
  group vendors/mediatek/lwip/src/netif/
    ../../../../../vendors/mediatek/lwip/src/netif/: ethernetif.c
  group libraries/logging/
    ../../../../../libraries/logging/: iot_logging_task_dynamic_buffers.c iot_logging.c
  group libraries/logging/include/
    ../../../../../libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group demos/dev_mode_key_provisioning/src/
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group demos/dev_mode_key_provisioning/include/
    ../../../../../demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group libraries/c_sdk/aws/defender/src/
    ../../../../../libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group libraries/c_sdk/aws/defender/src/private/
    ../../../../../libraries/c_sdk/aws/defender/src/private/: aws_iot_defender_internal.h
  group libraries/c_sdk/aws/defender/include/
    ../../../../../libraries/c_sdk/aws/defender/include/: aws_iot_defender.h
  group libraries/c_sdk/standard/mqtt/src/
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c iot_mqtt_context_connection.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_managed_function_wrapper.c iot_mqtt_subscription_container.c iot_mqtt_mutex_wrapper.c iot_mqtt_agent.c
  group libraries/coreMQTT/source/
    ../../../../../libraries/coreMQTT/source/: core_mqtt.c core_mqtt_state.c core_mqtt_serializer.c
  group libraries/coreMQTT/source/include/
    ../../../../../libraries/coreMQTT/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_serializer.h core_mqtt_state.h
  group libraries/coreMQTT/source/interface/
    ../../../../../libraries/coreMQTT/source/interface/: transport_interface.h
  group libraries/abstractions/backoff_algorithm/source/
    ../../../../../libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group libraries/abstractions/backoff_algorithm/source/include/
    ../../../../../libraries/abstractions/backoff_algorithm/source/include/: backoff_algorithm.h
  group demos/common/pkcs11_helpers/
    ../../../../../demos/common/pkcs11_helpers/: pkcs11_helpers.c
  group libraries/abstractions/transport/secure_sockets/
    ../../../../../libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.h transport_secure_sockets.c
  group libraries/c_sdk/standard/serializer/src/cbor/
    ../../../../../libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group libraries/c_sdk/standard/serializer/src/json/
    ../../../../../libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group libraries/c_sdk/standard/serializer/src/
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_serializer_static_memory.c iot_json_utils.c
  group libraries/c_sdk/standard/serializer/include/
    ../../../../../libraries/c_sdk/standard/serializer/include/: iot_serializer.h iot_json_utils.h
  group libraries/c_sdk/aws/shadow/src/
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group libraries/c_sdk/aws/shadow/include/
    ../../../../../libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group libraries/c_sdk/standard/https/src/
    ../../../../../libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group libraries/coreHTTP/source/
    ../../../../../libraries/coreHTTP/source/: core_http_client.c
  group libraries/coreHTTP/source/dependency/3rdparty/http_parser/
    ../../../../../libraries/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c http_parser.h
  group libraries/coreHTTP/source/include/
    ../../../../../libraries/coreHTTP/source/include/: core_http_client.h core_http_client_private.h core_http_config_defaults.h
  group libraries/coreHTTP/source/interface/
    ../../../../../libraries/coreHTTP/source/interface/: transport_interface.h
  group demos/common/http_demo_helpers/
    ../../../../../demos/common/http_demo_helpers/: http_demo_utils.c
  group libraries/freertos_plus/aws/greengrass/src/
    ../../../../../libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group libraries/freertos_plus/aws/greengrass/include/
    ../../../../../libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group libraries/freertos_plus/standard/freertos_plus_cli/source/
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/source/: FreeRTOS_CLI.c FreeRTOS_CLI_Console.c
  group libraries/coreJSON/source/
    ../../../../../libraries/coreJSON/source/: core_json.c
  group libraries/coreJSON/source/include/
    ../../../../../libraries/coreJSON/source/include/: core_json.h
  group libraries/device_shadow_for_aws/source/
    ../../../../../libraries/device_shadow_for_aws/source/: shadow.c
  group libraries/device_shadow_for_aws/source/include/
    ../../../../../libraries/device_shadow_for_aws/source/include/: shadow.h shadow_config_defaults.h
  group demos/common/mqtt_demo_helpers/
    ../../../../../demos/common/mqtt_demo_helpers/: mqtt_demo_helpers.c
  group demos/include/
    ../../../../../demos/include/: aws_iot_metrics.h
  group libraries/device_defender_for_aws/source/
    ../../../../../libraries/device_defender_for_aws/source/: defender.c
  group libraries/device_defender_for_aws/source/include/
    ../../../../../libraries/device_defender_for_aws/source/include/: defender.h defender_config_defaults.h
  group libraries/jobs_for_aws/source/
    ../../../../../libraries/jobs_for_aws/source/: jobs.c
  group libraries/jobs_for_aws/source/include/
    ../../../../../libraries/jobs_for_aws/source/include/: jobs.h
  group libraries/c_sdk/aws/defender/test/unit/
    ../../../../../libraries/c_sdk/aws/defender/test/unit/: aws_iot_tests_defender_unit.c
  group libraries/c_sdk/aws/defender/test/system/
    ../../../../../libraries/c_sdk/aws/defender/test/system/: aws_iot_tests_defender_system.c
  group libraries/c_sdk/aws/shadow/test/unit/
    ../../../../../libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
  group libraries/c_sdk/aws/shadow/test/system/
    ../../../../../libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
  group libraries/c_sdk/aws/shadow/test/
    ../../../../../libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
  group libraries/c_sdk/standard/common/test/
    ../../../../../libraries/c_sdk/standard/common/test/: iot_memory_leak.c iot_tests_taskpool.c
  group libraries/c_sdk/standard/https/test/unit/
    ../../../../../libraries/c_sdk/standard/https/test/unit/: iot_tests_https_client.c iot_tests_https_utils.c iot_tests_https_common.c iot_tests_https_sync.c iot_tests_https_async.c
  group libraries/c_sdk/standard/https/test/system/
    ../../../../../libraries/c_sdk/standard/https/test/system/: iot_tests_https_system.c
  group libraries/c_sdk/standard/mqtt/test/mock/
    ../../../../../libraries/c_sdk/standard/mqtt/test/mock/: iot_tests_mqtt_mock.c
  group libraries/c_sdk/standard/mqtt/test/unit/
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c iot_tests_mqtt_metrics.c
  group libraries/c_sdk/standard/mqtt/test/system/
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group libraries/c_sdk/standard/mqtt/test/
    ../../../../../libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
  group libraries/c_sdk/standard/serializer/test/
    ../../../../../libraries/c_sdk/standard/serializer/test/: iot_tests_serializer_cbor.c iot_tests_serializer_json.c iot_tests_deserializer_json.c
  group libraries/freertos_plus/aws/greengrass/test/
    ../../../../../libraries/freertos_plus/aws/greengrass/test/: aws_test_ggd_system.c aws_test_ggd_unit.c aws_test_helper_secure_connect.c
  group libraries/freertos_plus/standard/crypto/test/
    ../../../../../libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
  group libraries/freertos_plus/standard/freertos_plus_cli/utest/
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/utest/: iot_test_freertos_cli.c iot_test_freertos_cli_console.c
  group libraries/freertos_plus/standard/tls/test/
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group libraries/abstractions/pkcs11/test/
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
  group libraries/abstractions/platform/test/
    ../../../../../libraries/abstractions/platform/test/: iot_test_platform_clock.c iot_test_platform_threads.c
  group libraries/abstractions/secure_sockets/test/
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
  group libraries/abstractions/wifi/test/
    ../../../../../libraries/abstractions/wifi/test/: iot_test_wifi.c
  group tests/integration_test/
    ../../../../../tests/integration_test/: core_mqtt_system_test.c shadow_system_test.c core_http_system_test.c
  group vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/config_files/
    ../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/config_files/: FreeRTOSConfig.h FreeRTOSIPConfig.h aws_bufferpool_config.h aws_ggd_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_runner_config.h iot_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h core_http_config.h core_mqtt_config.h core_pkcs11_config.h core_test_pkcs11_config.h defender_config.h iot_config.h iot_mqtt_agent_config.h lwipopts.h shadow_config.h trcConfig.h trcSnapshotConfig.h unity_config.h
  group vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/
    ../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/: startup_mt7687.s
  group vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/application_code/
    ../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/application_code/: main.c
  group vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/application_code/mediatek_code/source/
    ../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/aws_tests/application_code/mediatek_code/source/: sys_init.c system_mt7687.c ept_gpio_var.c ept_eint_var.c
  group vendors/mediatek/sdk/kernel/service/src/
    ../../../../../vendors/mediatek/sdk/kernel/service/src/: exception_handler.c toi.c os_trace_callback.c os_port_callback.c memory_regions.c
  group libraries/3rdparty/mbedtls/library/
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/mbedtls/include/mbedtls/
    ../../../../../libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group libraries/3rdparty/mbedtls_utils/
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_utils.c mbedtls_error.h mbedtls_error.c
  group libraries/3rdparty/mbedtls_config/
    ../../../../../libraries/3rdparty/mbedtls_config/: threading_alt.h
  group libraries/3rdparty/pkcs11/
    ../../../../../libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group libraries/3rdparty/lwip/src/api/
    ../../../../../libraries/3rdparty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group libraries/3rdparty/lwip/src/core/
    ../../../../../libraries/3rdparty/lwip/src/core/: def.c dns.c inet_chksum.c init.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c timeouts.c udp.c pbuf.c tcp_out.c ip.c
  group libraries/3rdparty/lwip/src/core/ipv4/
    ../../../../../libraries/3rdparty/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c etharp.c
  group libraries/3rdparty/lwip/src/core/ipv6/
    ../../../../../libraries/3rdparty/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group libraries/3rdparty/lwip/src/netif/
    ../../../../../libraries/3rdparty/lwip/src/netif/: ethernet.c
  group libraries/3rdparty/lwip_osal/include/
    ../../../../../libraries/3rdparty/lwip_osal/include/: lwipopts_freertos.h
  group libraries/3rdparty/lwip_osal/include/arch/
    ../../../../../libraries/3rdparty/lwip_osal/include/arch/: cc.h perf.h sys_arch.h
  group libraries/3rdparty/lwip_osal/src/
    ../../../../../libraries/3rdparty/lwip_osal/src/: sys_arch.c
  group libraries/3rdparty/unity/src/
    ../../../../../libraries/3rdparty/unity/src/: unity.c unity.h unity_internals.h
  group libraries/3rdparty/unity/extras/fixture/src/
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group libraries/3rdparty/tinycbor/src/
    ../../../../../libraries/3rdparty/tinycbor/src/: cborpretty.c cborpretty_stdio.c cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c
  group libraries/3rdparty/jsmn/
    ../../../../../libraries/3rdparty/jsmn/: jsmn.h jsmn.c
